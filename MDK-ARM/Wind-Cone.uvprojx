# Keil uVision project Wind-Cone.uvprojx, settings and files
target Target 1 (5060528::V5.06 update 5 (build 528)::ARMCC)
  device: nRF51822_xxAA Nordic Semiconductor
  pack: NordicSemiconductor.nRF_DeviceFamilyPack.8.17.0
  cpu: IRAM(0x20000000-0x20003FFF) IROM(0-0x3FFFF) CLOCK(16000000) CPUTYPE("Cortex-M0") ESEL ELITTLE
  output: Wind-Cone
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: NRF51822 BOARD_PCA10028 NRF51
  c include: ..\Drivers;..\Inc;..\Src\Board Defintion;..\Src\Board Support;..\Src\nRF_Drivers;..\Src\nRF_Libraries;..\Src\nRF_log
  asm define: NRF51822 BOARD_PCA10028 NRF51
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x4000
  group Application
    ../Src/: main.c
  group Board Defintion
    ../Src/Board Defintion/: boards.c
  group Board Support
    ../Src/Board Support/: bsp.c bsp_nfc.c
  group nRF_Drivers
    ../Src/nRF_Drivers/: nrf_drv_common.c nrf_drv_gpiote.c nrf_drv_spi.c nrf_drv_uart.c
  group nRF_Libraries
    ../Src/nRF_Libraries/: app_button.c app_error.c app_error_weak.c app_timer.c app_util_platform.c nrf_assert.c sdk_errors.c
  group nRF_log
    ../Src/nRF_log/: nrf_log_frontend.c nrf_log_backend_serial.c
software components: CMSIS:CORE 5.0.1, Device:Startup 8.17.0, Device:StartupConfig 8.17.0
